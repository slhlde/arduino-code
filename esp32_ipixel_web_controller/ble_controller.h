#pragma once
#include <Arduino.h>
#include <NimBLEDevice.h>
#include <string>
#include <ctype.h>

static NimBLEUUID CHAR_UUID_WRITE("0000fa02-0000-1000-8000-00805f9b34fb");
static NimBLEUUID CHAR_UUID_NOTIFY("0000fa03-0000-1000-8000-00805f9b34fb");

// 8x16 基础点阵字模 (ASCII 32-90)
static const uint8_t FONT_8X16[][16] PROGMEM = {
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // Space
    {0x00,0x00,0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x00,0x00,0x18,0x18,0x00,0x00,0x00}, // !
    {0x00,0x36,0x36,0x36,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // "
    {0x00,0x00,0x36,0x36,0x7F,0x36,0x36,0x36,0x7F,0x36,0x36,0x00,0x00,0x00,0x00,0x00}, // #
    {0x00,0x18,0x3E,0x60,0x3C,0x06,0x7C,0x18,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // $
    {0x00,0x00,0x62,0x66,0x0C,0x18,0x30,0x66,0x46,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // %
    {0x00,0x38,0x6C,0x38,0x76,0xDC,0xCC,0x76,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // &
    {0x00,0x18,0x18,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // '
    {0x00,0x0C,0x18,0x30,0x30,0x30,0x30,0x18,0x0C,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // (
    {0x00,0x30,0x18,0x0C,0x0C,0x0C,0x0C,0x18,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // )
    {0x00,0x00,0x00,0x66,0x3C,0xFF,0x3C,0x66,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // *
    {0x00,0x00,0x00,0x18,0x18,0x7E,0x18,0x18,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // +
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x18,0x18,0x30,0x00,0x00,0x00,0x00,0x00}, // ,
    {0x00,0x00,0x00,0x00,0x00,0x7E,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // -
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x18,0x18,0x00,0x00,0x00,0x00,0x00,0x00}, // .
    {0x00,0x02,0x06,0x0C,0x18,0x30,0x60,0xC0,0x80,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // /
    {0x00,0x3C,0x66,0x6E,0x76,0x66,0x66,0x3C,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // 0
    {0x00,0x18,0x38,0x18,0x18,0x18,0x18,0x7E,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // 1
    {0x00,0x3C,0x66,0x06,0x0C,0x18,0x30,0x7E,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // 2
    {0x00,0x3C,0x66,0x06,0x1C,0x06,0x66,0x3C,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // 3
    {0x00,0x0C,0x1C,0x34,0x64,0x7E,0x04,0x0E,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // 4
    {0x00,0x7E,0x60,0x7C,0x06,0x06,0x66,0x3C,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // 5
    {0x00,0x1C,0x30,0x60,0x7C,0x66,0x66,0x3C,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // 6
    {0x00,0x7E,0x06,0x0C,0x18,0x30,0x30,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // 7
    {0x00,0x3C,0x66,0x66,0x3C,0x66,0x66,0x3C,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // 8
    {0x00,0x3C,0x66,0x66,0x3E,0x06,0x0C,0x38,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // 9
    {0x00,0x00,0x18,0x18,0x00,0x00,0x18,0x18,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // :
    {0x00,0x00,0x18,0x18,0x00,0x00,0x18,0x18,0x30,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // ;
    {0x00,0x06,0x0C,0x18,0x30,0x18,0x0C,0x06,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // <
    {0x00,0x00,0x7E,0x00,0x00,0x7E,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // =
    {0x00,0x60,0x30,0x18,0x0C,0x18,0x30,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // >
    {0x00,0x3C,0x66,0x06,0x0C,0x18,0x00,0x18,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // ?
    {0x00,0x3C,0x66,0x6E,0x6A,0x6E,0x60,0x3C,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // @
    {0x00,0x18,0x3C,0x66,0x7E,0x66,0x66,0x66,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // A
    {0x00,0x7C,0x66,0x7C,0x66,0x66,0x7C,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // B
    {0x00,0x3C,0x66,0x60,0x60,0x66,0x3C,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // C
    {0x00,0x78,0x6C,0x66,0x66,0x6C,0x78,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // D
    {0x00,0x7E,0x60,0x7C,0x60,0x60,0x7E,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // E
    {0x00,0x7E,0x60,0x7C,0x60,0x60,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // F
    {0x00,0x3C,0x66,0x60,0x6E,0x66,0x3E,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // G
    {0x00,0x66,0x66,0x7E,0x66,0x66,0x66,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // H
    {0x00,0x3C,0x18,0x18,0x18,0x18,0x3C,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // I
    {0x00,0x0E,0x06,0x06,0x06,0x66,0x3C,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // J
    {0x00,0x66,0x6C,0x78,0x78,0x6C,0x66,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // K
    {0x00,0x60,0x60,0x60,0x60,0x60,0x7E,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // L
    {0x00,0x63,0x77,0x7F,0x6B,0x63,0x63,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // M
    {0x00,0x66,0x76,0x7E,0x7E,0x6E,0x66,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // N
    {0x00,0x3C,0x66,0x66,0x66,0x66,0x3C,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // O
    {0x00,0x7C,0x66,0x7C,0x60,0x60,0x60,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // P
    {0x00,0x3C,0x66,0x66,0x66,0x6A,0x3C,0x06,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // Q
    {0x00,0x7C,0x66,0x7C,0x6C,0x66,0x63,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // R
    {0x00,0x3C,0x66,0x30,0x0C,0x66,0x3C,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // S
    {0x00,0x7E,0x18,0x18,0x18,0x18,0x18,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // T
    {0x00,0x66,0x66,0x66,0x66,0x66,0x3C,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // U
    {0x00,0x66,0x66,0x66,0x3C,0x3C,0x18,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // V
    {0x00,0x63,0x63,0x6B,0x7F,0x77,0x63,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // W
    {0x00,0x66,0x3C,0x18,0x3C,0x66,0x66,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // X
    {0x00,0x66,0x66,0x3C,0x18,0x18,0x18,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // Y
    {0x00,0x7E,0x0C,0x18,0x30,0x60,0x7E,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}  // Z
};

class BleController {
public:
    static NimBLEClient* pClient;
    static NimBLERemoteCharacteristic* pWriteChar;
    static NimBLERemoteCharacteristic* pNotifyChar;
    static NimBLEAddress targetAddr;

    static volatile bool deviceFound;
    static volatile bool isConnected;
    static volatile uint32_t nextScanAt;
    static int targetRSSI;
    static bool writeWithResponse;

    static String targetMacStr;
    static String lastNotifyHex;
    static String lastLog;

    static bool currentPower;
    static uint8_t currentBrightness;
    static uint8_t currentClockStyle;

    static void log(const String& msg) {
        lastLog = msg;
        Serial.println("[BLE] " + msg);
    }

    static void notifyCallback(NimBLERemoteCharacteristic* chr, uint8_t* data, size_t len, bool isNotify) {
        char buf[8];
        String hexStr = "";
        for (size_t i = 0; i < len; i++) {
            snprintf(buf, sizeof(buf), "%02X ", data[i]);
            hexStr += buf;
        }
        lastNotifyHex = hexStr;
    }

    class ClientCallbacks : public NimBLEClientCallbacks {
        void onConnect(NimBLEClient* client) override { log("硬件底层已连通"); }
        void onDisconnect(NimBLEClient* client, int reason) override {
            isConnected = false;
            pWriteChar = nullptr;
            pNotifyChar = nullptr;
            nextScanAt = millis() + 3000;
            log("屏幕断开 (" + String(reason) + ")");
        }
    };

    class ScanCallbacks : public NimBLEScanCallbacks {
        void onDiscovered(const NimBLEAdvertisedDevice* dev) override {
            if (deviceFound) return;
            std::string mac = dev->getAddress().toString();
            for (char& c : mac) c = tolower((unsigned char)c);
            String curTarget = targetMacStr;
            curTarget.toLowerCase();

            if (mac == curTarget.c_str()) {
                if (!dev->isConnectable()) return;
                targetAddr = dev->getAddress();
                targetRSSI = dev->getRSSI();
                deviceFound = true;
                log("🎯 抓取到目标屏幕！RSSI: " + String(targetRSSI) + " dBm");
            }
        }
    };

    static void releaseClient() {
        isConnected = false;
        pWriteChar = nullptr;
        pNotifyChar = nullptr;
        if (pClient) { NimBLEDevice::deleteClient(pClient); pClient = nullptr; }
    }

    static void startScan() {
        NimBLEScan* pScan = NimBLEDevice::getScan();
        if (pScan->isScanning()) return;
        deviceFound = false;
        pScan->setActiveScan(true);
        pScan->setInterval(200);
        pScan->setWindow(60);
        pScan->start(0, false);
    }

    static bool connectToServer() {
        if (targetAddr.isNull()) return false;
        releaseClient();

        pClient = NimBLEDevice::createClient();
        if (!pClient) return false;

        static ClientCallbacks cCb;
        pClient->setClientCallbacks(&cCb, false);
        pClient->setConnectTimeout(12000);

        if (!pClient->connect(targetAddr, true, false, true)) {
            releaseClient();
            return false;
        }

        for (auto* s : pClient->getServices(true)) {
            if (!s) continue;
            auto* wc = s->getCharacteristic(CHAR_UUID_WRITE);
            auto* nc = s->getCharacteristic(CHAR_UUID_NOTIFY);
            if (wc) pWriteChar = wc;
            if (nc) pNotifyChar = nc;
        }

        if (!pWriteChar) { releaseClient(); return false; }
        writeWithResponse = !pWriteChar->canWriteNoResponse();

        if (pNotifyChar && (pNotifyChar->canNotify() || pNotifyChar->canIndicate())) {
            pNotifyChar->subscribe(pNotifyChar->canNotify(), notifyCallback, true);
        }

        isConnected = true;
        log("🎉 屏幕连接就绪！");
        return true;
    }

    static void init(const String& mac) {
        targetMacStr = mac;
        NimBLEDevice::init("ESP32_iPixel_Central");
        NimBLEDevice::setPower(ESP_PWR_LVL_P9);
        static ScanCallbacks sCb;
        NimBLEScan* pScan = NimBLEDevice::getScan();
        pScan->setScanCallbacks(&sCb, false);
        startScan();
    }

    static bool sendCommand(const uint8_t* data, size_t len) {
        if (!isConnected || !pClient || !pClient->isConnected() || !pWriteChar) return false;
        return pWriteChar->writeValue(data, len, writeWithResponse);
    }

    static bool sendHex(String hex) {
        hex.replace(" ", ""); hex.replace(":", "");
        if (hex.length() % 2 != 0) return false;
        size_t len = hex.length() / 2;
        uint8_t* buf = (uint8_t*)malloc(len);
        for (size_t i = 0; i < len; i++) {
            buf[i] = (uint8_t)strtoul(hex.substring(i * 2, i * 2 + 2).c_str(), nullptr, 16);
        }
        bool ok = sendCommand(buf, len);
        free(buf);
        return ok;
    }

    static void setPower(bool on) {
        currentPower = on;
        uint8_t cmd[] = {0x05, 0x00, 0x07, 0x01, (uint8_t)(on ? 0x01 : 0x00)};
        sendCommand(cmd, sizeof(cmd));
    }

    static void setBrightness(uint8_t level) {
        level = constrain(level, 1, 100);
        currentBrightness = level;
        uint8_t cmd[] = {0x05, 0x00, 0x04, 0x80, level};
        sendCommand(cmd, sizeof(cmd));
    }

    static void setClockMode(uint8_t style, bool showDate = false, int h = 12, int m = 30, int s = 0) {
        if (style < 1) style = 1;
        if (style > 8) style = 8;
        currentClockStyle = style;

        uint8_t timeCmd[] = {0x08, 0x00, 0x01, 0x80, (uint8_t)h, (uint8_t)m, (uint8_t)s, 0x00};
        sendCommand(timeCmd, sizeof(timeCmd));
        delay(80);

        uint8_t clockCmd[] = {0x0B, 0x00, 0x06, 0x01, style, 0x01, (uint8_t)(showDate ? 0x01 : 0x00), 26, 5, 1, 1};
        sendCommand(clockCmd, sizeof(clockCmd));
        log("时钟样式 -> " + String(style) + (showDate ? " (含日期)" : " (无日期)"));
    }

    static uint32_t calcCrc32(const uint8_t *data, size_t length) {
        uint32_t crc = 0xFFFFFFFF;
        for (size_t i = 0; i < length; i++) {
            crc ^= data[i];
            for (int j = 0; j < 8; j++) crc = (crc >> 1) ^ (0xEDB88320 & (-(crc & 1)));
        }
        return ~crc;
    }

    static inline uint8_t reverseByte(uint8_t b) {
        b = (b & 0xF0) >> 4 | (b & 0x0F) << 4;
        b = (b & 0xCC) >> 2 | (b & 0x33) << 2;
        b = (b & 0xAA) >> 1 | (b & 0x55) << 1;
        return b;
    }

    // 点阵生成算法 (只保留极速的 8x16 与 16x32)
    static void renderGlyph(uint8_t fontIdx, uint8_t size, uint8_t* out) {
        if (size == 1) { // 8x16 (16 bytes)
            for (int k = 0; k < 16; k++) out[k] = reverseByte(pgm_read_byte(&(FONT_8X16[fontIdx][k])));
        } else { // size == 2: 16x32 (64 bytes, 高度满屏)
            for (int y = 0; y < 16; y++) {
                uint8_t r = pgm_read_byte(&(FONT_8X16[fontIdx][y]));
                uint8_t b0 = 0, b1 = 0;
                for (int bit = 0; bit < 4; bit++) {
                    if (r & (1 << (7 - bit))) b0 |= (0x03 << (bit * 2));
                    if (r & (1 << (3 - bit))) b1 |= (0x03 << (bit * 2));
                }
                size_t row = y * 4;
                out[row]     = b0; out[row + 1] = b1;
                out[row + 2] = b0; out[row + 3] = b1;
            }
        }
    }

    // 精炼 5 参数文本推送接口 (彻底去除无用参数)
    static bool sendText(const String& msg, uint8_t anim = 1, uint8_t speed = 90, String hexColor = "FF5500", uint8_t fontSize = 2) {
        if (!isConnected || msg.length() == 0) return false;

        anim = constrain(anim, 1, 8);
        speed = constrain(speed, 1, 100);
        fontSize = (fontSize == 1) ? 1 : 2;

        hexColor.replace("#", "");
        if (hexColor.length() < 6) hexColor = "FF5500";
        uint8_t r = strtoul(hexColor.substring(0, 2).c_str(), nullptr, 16);
        uint8_t g = strtoul(hexColor.substring(2, 4).c_str(), nullptr, 16);
        uint8_t b = strtoul(hexColor.substring(4, 6).c_str(), nullptr, 16);

        size_t charCount = msg.length();
        if (fontSize == 2 && charCount > 7) charCount = 7;   // 16x32 大字限 7 字符 (单包 512 极限)
        if (fontSize == 1 && charCount > 25) charCount = 25; // 8x16 标准字限 25 字符

        uint8_t flag = (fontSize == 1) ? 0x00 : 0x02;
        size_t bmpLen = (fontSize == 1) ? 16 : 64;
        size_t bytesPerChar = 4 + bmpLen;
        size_t payloadSize = 14 + (charCount * bytesPerChar);

        uint8_t* payload = (uint8_t*)malloc(payloadSize);
        if (!payload) return false;

        payload[0] = (uint8_t)(charCount & 0xFF);
        payload[1] = (uint8_t)((charCount >> 8) & 0xFF);
        payload[2] = 0x01; payload[3] = 0x00; // 默认对齐
        payload[4] = anim; payload[5] = speed;
        payload[6] = 0x01;
        payload[7] = r; payload[8] = g; payload[9] = b;
        payload[10] = 0; payload[11] = 0; payload[12] = 0; payload[13] = 0;

        for (size_t i = 0; i < charCount; i++) {
            char c = msg[i];
            uint8_t fontIdx = 0;
            if (c >= 32 && c <= 90) fontIdx = c - 32;
            else if (c >= 'a' && c <= 'z') fontIdx = (c - 'a' + 'A') - 32;

            size_t offset = 14 + (i * bytesPerChar);
            payload[offset] = flag;
            payload[offset + 1] = r; payload[offset + 2] = g; payload[offset + 3] = b;
            renderGlyph(fontIdx, fontSize, &payload[offset + 4]);
        }

        uint32_t crc = calcCrc32(payload, payloadSize);
        size_t totalLen = 15 + payloadSize;
        uint8_t* packet = (uint8_t*)malloc(totalLen);
        if (!packet) { free(payload); return false; }

        packet[0] = (uint8_t)(totalLen & 0xFF);
        packet[1] = (uint8_t)((totalLen >> 8) & 0xFF);
        packet[2] = 0x00; packet[3] = 0x01; packet[4] = 0x00;
        packet[5] = (uint8_t)(payloadSize & 0xFF);
        packet[6] = (uint8_t)((payloadSize >> 8) & 0xFF);
        packet[7] = (uint8_t)((payloadSize >> 16) & 0xFF);
        packet[8] = (uint8_t)((payloadSize >> 24) & 0xFF);
        packet[9] = (uint8_t)(crc & 0xFF);
        packet[10] = (uint8_t)((crc >> 8) & 0xFF);
        packet[11] = (uint8_t)((crc >> 16) & 0xFF);
        packet[12] = (uint8_t)((crc >> 24) & 0xFF);
        packet[13] = 0x00; packet[14] = 0x00;

        memcpy(&packet[15], payload, payloadSize);
        free(payload);

        bool ok = sendCommand(packet, totalLen);
        free(packet);
        log("✅ 推送文本: \"" + msg + "\" (字号:" + String(fontSize == 2 ? "16x32大字" : "8x16标准") + ")");
        return ok;
    }

    static void reconnect() {
        NimBLEScan* scan = NimBLEDevice::getScan();
        if (scan->isScanning()) scan->stop();
        releaseClient();
        nextScanAt = millis();
    }

    static void loop() {
        NimBLEScan* pScan = NimBLEDevice::getScan();
        if (deviceFound) {
            pScan->stop();
            delay(100);
            deviceFound = false;
            if (!connectToServer()) nextScanAt = millis() + 3000;
        }
        if (!isConnected && !deviceFound && !pScan->isScanning() && (int32_t)(millis() - nextScanAt) >= 0) {
            startScan();
        }
    }
};

NimBLEClient* BleController::pClient = nullptr;
NimBLERemoteCharacteristic* BleController::pWriteChar = nullptr;
NimBLERemoteCharacteristic* BleController::pNotifyChar = nullptr;
NimBLEAddress BleController::targetAddr;
volatile bool BleController::deviceFound = false;
volatile bool BleController::isConnected = false;
volatile uint32_t BleController::nextScanAt = 0;
int BleController::targetRSSI = 0;
bool BleController::writeWithResponse = false;
String BleController::targetMacStr = "";
String BleController::lastNotifyHex = "-";
String BleController::lastLog = "初始化...";
bool BleController::currentPower = true;
uint8_t BleController::currentBrightness = 60;
uint8_t BleController::currentClockStyle = 4;